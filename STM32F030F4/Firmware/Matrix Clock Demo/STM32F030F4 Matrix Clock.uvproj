# Keil uVision project STM32F030F4 Matrix Clock.uvproj, settings and files
target VGA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F031F6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Matrix Clock +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./: startup_stm32f030.s vga font.c vga font.h vga-min.c vga-min.h rcc.c gpio.h cmd.c fifo.c lib.c serial.c shell.c matrix.c hardware.h
